# Keil uVision project tw66gw02.uvprojx, settings and files
target tw66gw02 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: tw66gw02 +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File "..\PrepareFactoryBootImage.ps1"
  AfterMake: cmd.exe /C copy /Y "tw66gw02\\tw66gw02.hex" "tw66gw02.hex"
  AfterMake: cmd.exe /C copy /Y "tw66gw02\\tw66gw02.hex" "..\\tw66gw02.hex"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;../BSP;../COP;../OS
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\tw66gw02_factory.sct
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s boot_image.o
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group OS
    ../OS/: TaskScheduler.c
  group BSP
    ../BSP/: C8721.c key.c screen_c8721.c temp.c mathis_util.c wireless.c bh66f5242.c
  group COP
    ../COP/: main_control.c ota_boot.c ota_update.c shutdown.c start_up.c test.c warning.c
software components: CMSIS:CORE 4.3.0
