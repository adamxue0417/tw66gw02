LR_TEST 0x00000000 0x00100000 {
  ER_TEST 0x00000000 0x00100000 {
    startup.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_TEST 0x20000000 0x00100000 {
    .ANY (+RW +ZI)
  }
}
