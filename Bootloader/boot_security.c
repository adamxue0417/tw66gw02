#include "boot_api.h"
#include "boot_security.h"
#include "ota_layout.h"
#include "bearssl_hash.h"
#include "bearssl_rsa.h"
#include "inner.h"

/* Raw modulus retained for audit/reference; the verifier uses i15 form below. */
#if 0
static const unsigned char s_dev_modulus[384] =
{
    0xC7u, 0xC3u, 0xB5u, 0x53u, 0xC3u, 0xFAu, 0xA3u, 0xDCu, 0xC5u, 0x3Bu, 0xADu, 0x0Cu,
    0x55u, 0xC0u, 0x08u, 0x44u, 0xCCu, 0x5Cu, 0x55u, 0x2Cu, 0x6Eu, 0x14u, 0xB9u, 0x37u,
    0xBFu, 0xCFu, 0x38u, 0x65u, 0xD8u, 0x24u, 0xD7u, 0xD3u, 0x32u, 0xF4u, 0xC8u, 0x61u,
    0xEDu, 0x4Bu, 0xC0u, 0xD2u, 0x20u, 0xD6u, 0xA9u, 0x70u, 0x7Fu, 0x6Cu, 0xB5u, 0x90u,
    0x94u, 0x43u, 0xB5u, 0xB9u, 0x01u, 0x07u, 0x43u, 0x17u, 0x1Du, 0x8Fu, 0xB9u, 0xD5u,
    0xE7u, 0x82u, 0xA8u, 0x09u, 0xBDu, 0x60u, 0xA3u, 0xAEu, 0x94u, 0x9Au, 0x32u, 0x4Eu,
    0x94u, 0xFAu, 0xEDu, 0x11u, 0xD2u, 0x6Du, 0xDCu, 0xDAu, 0x83u, 0x46u, 0x07u, 0xB9u,
    0x53u, 0xBBu, 0x0Cu, 0x1Au, 0xF6u, 0x1Bu, 0xA7u, 0x8Fu, 0xE0u, 0x2Cu, 0xCFu, 0x92u,
    0xB3u, 0x52u, 0x47u, 0xB3u, 0xC9u, 0x94u, 0x90u, 0x9Cu, 0x88u, 0x9Fu, 0x80u, 0xCEu,
    0x8Du, 0x58u, 0x65u, 0x98u, 0x0Bu, 0x7Au, 0xAFu, 0x5Eu, 0xF9u, 0x31u, 0x6Du, 0x3Cu,
    0x1Bu, 0x52u, 0x7Cu, 0xDDu, 0x27u, 0xACu, 0xFAu, 0x4Cu, 0xB8u, 0x2Cu, 0x27u, 0xD0u,
    0x7Eu, 0x06u, 0x07u, 0x79u, 0x62u, 0x95u, 0xBDu, 0x17u, 0xAEu, 0xBCu, 0x9Cu, 0x4Eu,
    0x35u, 0xC7u, 0x2Cu, 0x0Au, 0xD8u, 0xEBu, 0x4Bu, 0xDDu, 0x96u, 0x66u, 0x6Eu, 0x8Au,
    0x77u, 0xBCu, 0xB2u, 0xA8u, 0xD2u, 0x14u, 0xD4u, 0xAEu, 0xE1u, 0x15u, 0x83u, 0xFFu,
    0x03u, 0x29u, 0xCCu, 0x48u, 0xD3u, 0xC4u, 0xDAu, 0x0Au, 0x4Du, 0x28u, 0xDDu, 0xD9u,
    0x6Bu, 0x5Fu, 0x3Fu, 0xCAu, 0xF5u, 0xDBu, 0x3Fu, 0x9Cu, 0x59u, 0x57u, 0x74u, 0xCFu,
    0x0Cu, 0xB1u, 0x2Cu, 0x8Bu, 0xBEu, 0x39u, 0x04u, 0x33u, 0xB9u, 0xD0u, 0x63u, 0xD3u,
    0xE6u, 0xC6u, 0x31u, 0x43u, 0x68u, 0x04u, 0x2Du, 0x7Cu, 0x5Bu, 0x3Au, 0x46u, 0xABu,
    0xB1u, 0xFFu, 0xF5u, 0x4Cu, 0x5Au, 0x21u, 0x20u, 0xF2u, 0xA1u, 0x0Au, 0xC3u, 0x2Au,
    0x12u, 0xDAu, 0xDBu, 0x79u, 0xEAu, 0x44u, 0x2Eu, 0x7Cu, 0x02u, 0x26u, 0x45u, 0x2Eu,
    0x28u, 0xF3u, 0xDEu, 0x1Du, 0x47u, 0x7Fu, 0xAAu, 0x58u, 0x9Cu, 0xAEu, 0x11u, 0x25u,
    0x08u, 0x98u, 0x89u, 0xF8u, 0x48u, 0x26u, 0x34u, 0x46u, 0x0Au, 0xAEu, 0xBBu, 0x9Cu,
    0x31u, 0xCEu, 0xE5u, 0x2Fu, 0x86u, 0x11u, 0xA7u, 0xF1u, 0x7Eu, 0xF7u, 0x22u, 0x13u,
    0x88u, 0xB1u, 0x1Eu, 0x2Fu, 0x69u, 0x9Cu, 0xBCu, 0x4Au, 0x8Fu, 0x78u, 0x30u, 0xB5u,
    0xFFu, 0x35u, 0x84u, 0x3Du, 0x59u, 0x6Fu, 0xFFu, 0x03u, 0xCAu, 0xF2u, 0xF2u, 0xCBu,
    0xE5u, 0xF9u, 0x1Eu, 0x7Fu, 0x83u, 0x1Bu, 0x5Bu, 0xDCu, 0xCCu, 0x63u, 0x77u, 0x4Bu,
    0x6Bu, 0x7Du, 0xA5u, 0x8Du, 0x08u, 0x3Au, 0xAFu, 0xA1u, 0x3Eu, 0x23u, 0xC8u, 0xD4u,
    0x02u, 0x71u, 0x98u, 0xD6u, 0xE7u, 0xDDu, 0x10u, 0xF6u, 0x30u, 0xF8u, 0xD4u, 0x12u,
    0x02u, 0x90u, 0xADu, 0x80u, 0x0Fu, 0x4Cu, 0xF2u, 0xDBu, 0xFAu, 0xB4u, 0xF6u, 0xCBu,
    0x0Fu, 0xC6u, 0x41u, 0xC1u, 0x96u, 0xF0u, 0x92u, 0x85u, 0x72u, 0x1Fu, 0x3Fu, 0xD8u,
    0x79u, 0xA2u, 0x95u, 0xEAu, 0x2Du, 0xFAu, 0x7Cu, 0x16u, 0xFBu, 0x70u, 0xB3u, 0xC1u,
    0x2Au, 0x1Eu, 0x08u, 0x03u, 0x9Du, 0x5Du, 0x1Cu, 0x4Cu, 0x40u, 0xEEu, 0x00u, 0xE3u
};
#endif

static const unsigned char s_dev_exponent[3] = {0x01u, 0x00u, 0x01u};

/*
 * BearSSL's generic public-key path decodes the immutable modulus into a
 * second stack buffer on every call.  Keeping the i15 form in read-only
 * Flash removes that redundant 412-byte stack allocation while preserving
 * the upstream i15 arithmetic and PKCS#1 unpadding.
 */
#define DEV_I15_FWLEN       (206u)
#define DEV_I15_TEMP_WORDS  (416u)
static const uint16_t s_dev_modulus_i15[DEV_I15_FWLEN] =
{
    0x0C00u, 0x00E3u, 0x01DCu, 0x7131u, 0x6AE8u, 0x0039u, 0x43C1u, 0x704Au,
    0x3859u, 0x16FBu, 0x74F8u, 0x28B7u, 0x14AFu, 0x079Au, 0x67FBu, 0x5C87u,
    0x4942u, 0x16F0u, 0x0383u, 0x3F19u, 0x3658u, 0x2B4Fu, 0x5B7Fu, 0x533Cu,
    0x4007u, 0x10ADu, 0x2405u, 0x6350u, 0x3187u, 0x510Fu, 0x5CFBu, 0x6635u,
    0x0138u, 0x48D4u, 0x7C47u, 0x3E84u, 0x41D5u, 0x58D0u, 0x6FB4u, 0x52DAu,
    0x31BBu, 0x5CCCu, 0x36B7u, 0x7E0Cu, 0x48F3u, 0x3E5Fu, 0x5E59u, 0x72BCu,
    0x7F81u, 0x596Fu, 0x087Au, 0x7CD6u, 0x05AFu, 0x7783u, 0x0951u, 0x672Fu,
    0x17B4u, 0x311Eu, 0x2711u, 0x5C88u, 0x0BF7u, 0x1A7Fu, 0x70C2u, 0x394Bu,
    0x18E7u, 0x3B9Cu, 0x155Du, 0x5118u, 0x4131u, 0x1F84u, 0x1311u, 0x4942u,
    0x5708u, 0x589Cu, 0x7F54u, 0x751Du, 0x1EF0u, 0x628Fu, 0x48A5u, 0x0089u,
    0x173Eu, 0x6A44u, 0x36F3u, 0x4B6Bu, 0x1950u, 0x10ACu, 0x1E54u, 0x0848u,
    0x262Du, 0x7FF5u, 0x5763u, 0x691Au, 0x62D9u, 0x42D7u, 0x6D00u, 0x0C50u,
    0x7363u, 0x63D3u, 0x73A0u, 0x10CEu, 0x71C8u, 0x48BBu, 0x1625u, 0x33C3u,
    0x2BBAu, 0x1C59u, 0x367Fu, 0x2BD7u, 0x79FEu, 0x16B5u, 0x1BBBu, 0x134Au,
    0x6D05u, 0x53C4u, 0x1891u, 0x0CA7u, 0x1FF8u, 0x1158u, 0x15DCu, 0x0535u,
    0x5469u, 0x3CB2u, 0x14EFu, 0x19BAu, 0x6CB3u, 0x34BDu, 0x5B1Du, 0x4B02u,
    0x1AE3u, 0x1C4Eu, 0x5D79u, 0x745Eu, 0x14ADu, 0x7796u, 0x40C0u, 0x741Fu,
    0x1613u, 0x4CB8u, 0x59F4u, 0x749Eu, 0x13E6u, 0x41B5u, 0x2DA7u, 0x3E4Cu,
    0x57AFu, 0x0B7Au, 0x4B30u, 0x3561u, 0x0674u, 0x09F8u, 0x1391u, 0x6524u,
    0x59E4u, 0x5247u, 0x2566u, 0x333Eu, 0x7F01u, 0x3A78u, 0x5EC3u, 0x4306u,
    0x29DDu, 0x07B9u, 0x068Cu, 0x736Au, 0x136Eu, 0x511Du, 0x1F5Du, 0x13A5u,
    0x4D19u, 0x2E94u, 0x4147u, 0x26F5u, 0x1540u, 0x5E78u, 0x773Au, 0x4763u,
    0x218Bu, 0x0107u, 0x6B72u, 0x510Eu, 0x2C84u, 0x76CBu, 0x2E0Fu, 0x35AAu,
    0x6910u, 0x4BC0u, 0x43DAu, 0x5321u, 0x1997u, 0x4D7Du, 0x3B04u, 0x4E19u,
    0x5FE7u, 0x3937u, 0x5C29u, 0x54B1u, 0x62E2u, 0x044Cu, 0x3801u, 0x4315u,
    0x1DD6u, 0x5CC5u, 0x7547u, 0x4F0Fu, 0x1DAAu, 0x0C7Cu
};

static uint32_t DevRsaPkcs1Verify(const unsigned char *signature,
                                  unsigned char *hash_out)
{
    uint16_t temporary[1u + DEV_I15_FWLEN + DEV_I15_TEMP_WORDS];
    uint16_t *decoded = temporary;
    uint16_t *work;
    unsigned char *encoded;

    if ((((uintptr_t)decoded) & 2u) == 0u) { decoded++; }
    work = decoded + DEV_I15_FWLEN;
    if (br_i15_decode_mod(decoded, signature, OTA_SIGNATURE_SIZE,
                          s_dev_modulus_i15) == 0u) {
        return 0u;
    }
    br_i15_modpow_opt(decoded, s_dev_exponent, sizeof(s_dev_exponent),
                      s_dev_modulus_i15, 0x3B35u,
                      work, DEV_I15_TEMP_WORDS);

    /* The exponentiation scratch is dead now; reuse it for encoded output. */
    encoded = (unsigned char *)work;
    br_i15_encode(encoded, OTA_SIGNATURE_SIZE, decoded);
    return br_rsa_pkcs1_sig_unpad(encoded,
                                  OTA_SIGNATURE_SIZE,
                                  BR_HASH_OID_SHA256, 32u, hash_out);
}

static uint16_t SecurityToken(uint8_t version)
{
    return (uint16_t)(0xA500u | version);
}

static uint32_t ReadCopyFloor(uint32_t offset)
{
    uint32_t index;
    uint32_t floor = OTA_SECURITY_BASELINE;
    const uint16_t *entries = (const uint16_t *)(OTA_SECURITY_BASE + offset);
    for (index = 0u; index < OTA_SECURITY_ENTRY_COUNT; index++) {
        uint8_t version = (uint8_t)(OTA_SECURITY_BASELINE + index);
        if (entries[index] != SecurityToken(version)) { break; }
        floor = version;
    }
    return floor;
}

uint32_t BootSecurity_ReadFloor(void)
{
    const uint32_t *header = (const uint32_t *)OTA_SECURITY_BASE;
    uint32_t a;
    uint32_t b;
    if ((header[0] != OTA_SECURITY_MAGIC) ||
        (header[1] != OTA_SECURITY_MAGIC_INV) ||
        ((uint16_t)header[2] != OTA_SECURITY_FORMAT)) {
        return 0xFFFFFFFFu;
    }
    a = ReadCopyFloor(OTA_SECURITY_COPY_A_OFFSET);
    b = ReadCopyFloor(OTA_SECURITY_COPY_B_OFFSET);
    return (a > b) ? a : b;
}

uint32_t BootSecurity_VerifyArtifact(uint32_t artifact_address,
                                     uint32_t application_size,
                                     uint32_t artifact_size)
{
    br_sha256_context sha;
    unsigned char expected_hash[32];
    unsigned char signed_hash[32];
    const unsigned char *signature;
    uint32_t mismatch = 0u;
    uint32_t i;

    if ((artifact_address < OTA_APP_BASE) ||
        (application_size < OTA_VECTOR_BYTES) ||
        (application_size > OTA_MAX_APPLICATION_SIZE) ||
        (artifact_size != (application_size + OTA_SIGNATURE_SIZE)) ||
        (artifact_size > OTA_MAX_ARTIFACT_SIZE) ||
        ((artifact_address + artifact_size) < artifact_address) ||
        ((artifact_address + artifact_size) > OTA_FLASH_END)) {
        return 0u;
    }

    br_sha256_init(&sha);
    br_sha256_update(&sha, (const void *)artifact_address, application_size);
    br_sha256_out(&sha, expected_hash);

    signature = (const unsigned char *)(artifact_address + application_size);

    if (DevRsaPkcs1Verify(signature, signed_hash) == 0u) {
        return 0u;
    }
    for (i = 0u; i < sizeof(expected_hash); i++) {
        mismatch |= (uint32_t)(expected_hash[i] ^ signed_hash[i]);
    }
    return (mismatch == 0u) ? MATHIS_VERIFY_KEY_DEV : 0u;
}

__attribute__((section("BOOT_API"), used))
const MathisBootApi g_mathis_boot_api =
{
    MATHIS_BOOT_API_MAGIC,
    MATHIS_BOOT_API_ABI_VERSION,
    sizeof(MathisBootApi),
    MATHIS_BOOT_CAP_DEV_KEY | MATHIS_BOOT_CAP_ANTIROLLBACK,
    2u,
    BootSecurity_VerifyArtifact,
    BootSecurity_ReadFloor,
    {
        0x3Fu, 0xCCu, 0xDCu, 0xB7u, 0x27u, 0x51u, 0x4Fu, 0x80u,
        0xA2u, 0x64u, 0xFEu, 0xC7u, 0x69u, 0x33u, 0xC3u, 0x05u,
        0x26u, 0x2Du, 0x3Cu, 0xE9u, 0x2Fu, 0x91u, 0xF8u, 0xA9u,
        0x71u, 0x1Eu, 0x4Eu, 0xECu, 0x1Au, 0x84u, 0xC0u, 0xD4u
    },
    0xFFFFFFFFu
};
